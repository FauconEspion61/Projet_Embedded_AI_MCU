<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32_Projet_Embedded_AI_MCU.ewp</path>
  </project>
  <batchBuild />
</workspace>
